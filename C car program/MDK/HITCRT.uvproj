# Keil uVision project HITCRT.uvproj, settings and files
target HITCRT (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: HITCRT +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\src\UCOSII;..\src\HITCRT_API;..\src\HITCRT_ROBOT_CTRL;..\src\HITCRT_TYPES;..\src\lib;..\src\lib\StartUp;..\src\HITCRT_ROBOT_CTRL\Preference;..\src\FAT;..\PC&ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group HITCRT_Types
    ../src/HITCRT_TYPES/: HITCRT_Coff.h HITCRT_RobotTypes.h HITCRT_Types.h Select.h
    ../src/HITCRT_TYPES/Preference/: Preference.h
  group HITCRT_API
    ../src/HITCRT_API/: hal.c CAN.c FSMC.c GPIO.c NVIC.c RCC.c TIM.c UART.c FPGA_REGS.h HITCRT_API.c HITCRT_API.h MotorDef.h HITCRT_STM32.h FlashSave.c
  group HITCRT_ROBOT_CTRL
    ../src/HITCRT_ROBOT_CTRL/: Robot.h RobotConfig.h RobotCtrl.h HITCRT_Algorithm.h HITCRT_Algorithm.c Location.c Location.h MotorConfig.h MotorCtrl.c Navigation.c Navigation.h CAN_API.c CAN_API.H IrComm.c IrComm.h
  group usr
    ../src/lib/: system_stm32f4xx.c
    ../src/HITCRT_ROBOT_CTRL/Preference/: PrivateFunction.h Action_Motor.h OS.h Path.h PrivateFunction.c RobotCtrl.c
    ../src/: stm32f4xx_it.c
  group lib
    ../src/lib/: misc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STARTUP
    ../src/lib/StartUp/: startup_stm32f4xx.s
  group UCOSII
    ../src/UCOSII/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group OS_PORT
    ../src/UCOSII/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c ucos_ii.h
  group FAT
    ../src/FAT/: sd.c tff.c
  group PC_ARM
    ../PC&ARM/: PC_ARM.h PC_Comm_Structs.h
